# Keil uVision project mediacenterproject.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: mediacenterproject
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration / Libraries
    ./: core_cm3.c
  group Source Files
    ./: mainmenu.c GLCD_SPI_LPC1700.c IRQ.c KBD.c LED.c ADC.c photogallery.c ARM_Ani_16bpp.c Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c shane.c granny.c Lewis.c
